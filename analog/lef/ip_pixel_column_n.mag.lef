VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO ip_pixel_column_n
  CLASS BLOCK ;
  FOREIGN ip_pixel_column_n ;
  ORIGIN 0.000 0.000 ;
  SIZE 480.000 BY 987.500 ;
  OBS
      LAYER Pwell ;
        RECT 0.000 970.000 14.000 987.500 ;
      LAYER Nwell ;
        RECT 14.000 970.000 480.000 987.500 ;
        RECT 0.000 960.000 480.000 970.000 ;
      LAYER Pwell ;
        RECT 0.000 959.500 480.000 960.000 ;
        RECT 0.000 948.300 0.500 959.500 ;
      LAYER Nwell ;
        RECT 0.500 948.300 480.000 959.500 ;
      LAYER Pwell ;
        RECT 0.000 945.000 7.800 948.300 ;
      LAYER Nwell ;
        RECT 7.800 945.000 480.000 948.300 ;
      LAYER Pwell ;
        RECT 0.000 944.500 480.000 945.000 ;
        RECT 0.000 933.300 0.500 944.500 ;
      LAYER Nwell ;
        RECT 0.500 933.300 480.000 944.500 ;
      LAYER Pwell ;
        RECT 0.000 930.000 7.800 933.300 ;
      LAYER Nwell ;
        RECT 7.800 930.000 480.000 933.300 ;
      LAYER Pwell ;
        RECT 0.000 929.500 480.000 930.000 ;
        RECT 0.000 918.300 0.500 929.500 ;
      LAYER Nwell ;
        RECT 0.500 918.300 480.000 929.500 ;
      LAYER Pwell ;
        RECT 0.000 915.000 7.800 918.300 ;
      LAYER Nwell ;
        RECT 7.800 915.000 480.000 918.300 ;
      LAYER Pwell ;
        RECT 0.000 914.500 480.000 915.000 ;
        RECT 0.000 903.300 0.500 914.500 ;
      LAYER Nwell ;
        RECT 0.500 903.300 480.000 914.500 ;
      LAYER Pwell ;
        RECT 0.000 900.000 7.800 903.300 ;
      LAYER Nwell ;
        RECT 7.800 900.000 480.000 903.300 ;
      LAYER Pwell ;
        RECT 0.000 899.500 480.000 900.000 ;
        RECT 0.000 888.300 0.500 899.500 ;
      LAYER Nwell ;
        RECT 0.500 888.300 480.000 899.500 ;
      LAYER Pwell ;
        RECT 0.000 885.000 7.800 888.300 ;
      LAYER Nwell ;
        RECT 7.800 885.000 480.000 888.300 ;
      LAYER Pwell ;
        RECT 0.000 884.500 480.000 885.000 ;
        RECT 0.000 873.300 0.500 884.500 ;
      LAYER Nwell ;
        RECT 0.500 873.300 480.000 884.500 ;
      LAYER Pwell ;
        RECT 0.000 870.000 7.800 873.300 ;
      LAYER Nwell ;
        RECT 7.800 870.000 480.000 873.300 ;
      LAYER Pwell ;
        RECT 0.000 869.500 480.000 870.000 ;
        RECT 0.000 858.300 0.500 869.500 ;
      LAYER Nwell ;
        RECT 0.500 858.300 480.000 869.500 ;
      LAYER Pwell ;
        RECT 0.000 855.000 7.800 858.300 ;
      LAYER Nwell ;
        RECT 7.800 855.000 480.000 858.300 ;
      LAYER Pwell ;
        RECT 0.000 854.500 480.000 855.000 ;
        RECT 0.000 843.300 0.500 854.500 ;
      LAYER Nwell ;
        RECT 0.500 843.300 480.000 854.500 ;
      LAYER Pwell ;
        RECT 0.000 840.000 7.800 843.300 ;
      LAYER Nwell ;
        RECT 7.800 840.000 480.000 843.300 ;
      LAYER Pwell ;
        RECT 0.000 839.500 480.000 840.000 ;
        RECT 0.000 828.300 0.500 839.500 ;
      LAYER Nwell ;
        RECT 0.500 828.300 480.000 839.500 ;
      LAYER Pwell ;
        RECT 0.000 825.000 7.800 828.300 ;
      LAYER Nwell ;
        RECT 7.800 825.000 480.000 828.300 ;
      LAYER Pwell ;
        RECT 0.000 824.500 480.000 825.000 ;
        RECT 0.000 813.300 0.500 824.500 ;
      LAYER Nwell ;
        RECT 0.500 813.300 480.000 824.500 ;
      LAYER Pwell ;
        RECT 0.000 810.000 7.800 813.300 ;
      LAYER Nwell ;
        RECT 7.800 810.000 480.000 813.300 ;
      LAYER Pwell ;
        RECT 0.000 809.500 480.000 810.000 ;
        RECT 0.000 798.300 0.500 809.500 ;
      LAYER Nwell ;
        RECT 0.500 798.300 480.000 809.500 ;
      LAYER Pwell ;
        RECT 0.000 795.000 7.800 798.300 ;
      LAYER Nwell ;
        RECT 7.800 795.000 480.000 798.300 ;
      LAYER Pwell ;
        RECT 0.000 794.500 480.000 795.000 ;
        RECT 0.000 783.300 0.500 794.500 ;
      LAYER Nwell ;
        RECT 0.500 783.300 480.000 794.500 ;
      LAYER Pwell ;
        RECT 0.000 780.000 7.800 783.300 ;
      LAYER Nwell ;
        RECT 7.800 780.000 480.000 783.300 ;
      LAYER Pwell ;
        RECT 0.000 779.500 480.000 780.000 ;
        RECT 0.000 768.300 0.500 779.500 ;
      LAYER Nwell ;
        RECT 0.500 768.300 480.000 779.500 ;
      LAYER Pwell ;
        RECT 0.000 765.000 7.800 768.300 ;
      LAYER Nwell ;
        RECT 7.800 765.000 480.000 768.300 ;
      LAYER Pwell ;
        RECT 0.000 764.500 480.000 765.000 ;
        RECT 0.000 753.300 0.500 764.500 ;
      LAYER Nwell ;
        RECT 0.500 753.300 480.000 764.500 ;
      LAYER Pwell ;
        RECT 0.000 750.000 7.800 753.300 ;
      LAYER Nwell ;
        RECT 7.800 750.000 480.000 753.300 ;
      LAYER Pwell ;
        RECT 0.000 749.500 480.000 750.000 ;
        RECT 0.000 738.300 0.500 749.500 ;
      LAYER Nwell ;
        RECT 0.500 738.300 480.000 749.500 ;
      LAYER Pwell ;
        RECT 0.000 735.000 7.800 738.300 ;
      LAYER Nwell ;
        RECT 7.800 735.000 480.000 738.300 ;
      LAYER Pwell ;
        RECT 0.000 734.500 480.000 735.000 ;
        RECT 0.000 723.300 0.500 734.500 ;
      LAYER Nwell ;
        RECT 0.500 723.300 480.000 734.500 ;
      LAYER Pwell ;
        RECT 0.000 720.000 7.800 723.300 ;
      LAYER Nwell ;
        RECT 7.800 720.000 480.000 723.300 ;
      LAYER Pwell ;
        RECT 0.000 719.500 480.000 720.000 ;
        RECT 0.000 708.300 0.500 719.500 ;
      LAYER Nwell ;
        RECT 0.500 708.300 480.000 719.500 ;
      LAYER Pwell ;
        RECT 0.000 705.000 7.800 708.300 ;
      LAYER Nwell ;
        RECT 7.800 705.000 480.000 708.300 ;
      LAYER Pwell ;
        RECT 0.000 704.500 480.000 705.000 ;
        RECT 0.000 693.300 0.500 704.500 ;
      LAYER Nwell ;
        RECT 0.500 693.300 480.000 704.500 ;
      LAYER Pwell ;
        RECT 0.000 690.000 7.800 693.300 ;
      LAYER Nwell ;
        RECT 7.800 690.000 480.000 693.300 ;
      LAYER Pwell ;
        RECT 0.000 689.500 480.000 690.000 ;
        RECT 0.000 678.300 0.500 689.500 ;
      LAYER Nwell ;
        RECT 0.500 678.300 480.000 689.500 ;
      LAYER Pwell ;
        RECT 0.000 675.000 7.800 678.300 ;
      LAYER Nwell ;
        RECT 7.800 675.000 480.000 678.300 ;
      LAYER Pwell ;
        RECT 0.000 674.500 480.000 675.000 ;
        RECT 0.000 663.300 0.500 674.500 ;
      LAYER Nwell ;
        RECT 0.500 663.300 480.000 674.500 ;
      LAYER Pwell ;
        RECT 0.000 660.000 7.800 663.300 ;
      LAYER Nwell ;
        RECT 7.800 660.000 480.000 663.300 ;
      LAYER Pwell ;
        RECT 0.000 659.500 480.000 660.000 ;
        RECT 0.000 648.300 0.500 659.500 ;
      LAYER Nwell ;
        RECT 0.500 648.300 480.000 659.500 ;
      LAYER Pwell ;
        RECT 0.000 645.000 7.800 648.300 ;
      LAYER Nwell ;
        RECT 7.800 645.000 480.000 648.300 ;
      LAYER Pwell ;
        RECT 0.000 644.500 480.000 645.000 ;
        RECT 0.000 633.300 0.500 644.500 ;
      LAYER Nwell ;
        RECT 0.500 633.300 480.000 644.500 ;
      LAYER Pwell ;
        RECT 0.000 630.000 7.800 633.300 ;
      LAYER Nwell ;
        RECT 7.800 630.000 480.000 633.300 ;
      LAYER Pwell ;
        RECT 0.000 629.500 480.000 630.000 ;
        RECT 0.000 618.300 0.500 629.500 ;
      LAYER Nwell ;
        RECT 0.500 618.300 480.000 629.500 ;
      LAYER Pwell ;
        RECT 0.000 615.000 7.800 618.300 ;
      LAYER Nwell ;
        RECT 7.800 615.000 480.000 618.300 ;
      LAYER Pwell ;
        RECT 0.000 614.500 480.000 615.000 ;
        RECT 0.000 603.300 0.500 614.500 ;
      LAYER Nwell ;
        RECT 0.500 603.300 480.000 614.500 ;
      LAYER Pwell ;
        RECT 0.000 600.000 7.800 603.300 ;
      LAYER Nwell ;
        RECT 7.800 600.000 480.000 603.300 ;
      LAYER Pwell ;
        RECT 0.000 599.500 480.000 600.000 ;
        RECT 0.000 588.300 0.500 599.500 ;
      LAYER Nwell ;
        RECT 0.500 588.300 480.000 599.500 ;
      LAYER Pwell ;
        RECT 0.000 585.000 7.800 588.300 ;
      LAYER Nwell ;
        RECT 7.800 585.000 480.000 588.300 ;
      LAYER Pwell ;
        RECT 0.000 584.500 480.000 585.000 ;
        RECT 0.000 573.300 0.500 584.500 ;
      LAYER Nwell ;
        RECT 0.500 573.300 480.000 584.500 ;
      LAYER Pwell ;
        RECT 0.000 570.000 7.800 573.300 ;
      LAYER Nwell ;
        RECT 7.800 570.000 480.000 573.300 ;
      LAYER Pwell ;
        RECT 0.000 569.500 480.000 570.000 ;
        RECT 0.000 558.300 0.500 569.500 ;
      LAYER Nwell ;
        RECT 0.500 558.300 480.000 569.500 ;
      LAYER Pwell ;
        RECT 0.000 555.000 7.800 558.300 ;
      LAYER Nwell ;
        RECT 7.800 555.000 480.000 558.300 ;
      LAYER Pwell ;
        RECT 0.000 554.500 480.000 555.000 ;
        RECT 0.000 543.300 0.500 554.500 ;
      LAYER Nwell ;
        RECT 0.500 543.300 480.000 554.500 ;
      LAYER Pwell ;
        RECT 0.000 540.000 7.800 543.300 ;
      LAYER Nwell ;
        RECT 7.800 540.000 480.000 543.300 ;
      LAYER Pwell ;
        RECT 0.000 539.500 480.000 540.000 ;
        RECT 0.000 528.300 0.500 539.500 ;
      LAYER Nwell ;
        RECT 0.500 528.300 480.000 539.500 ;
      LAYER Pwell ;
        RECT 0.000 525.000 7.800 528.300 ;
      LAYER Nwell ;
        RECT 7.800 525.000 480.000 528.300 ;
      LAYER Pwell ;
        RECT 0.000 524.500 480.000 525.000 ;
        RECT 0.000 513.300 0.500 524.500 ;
      LAYER Nwell ;
        RECT 0.500 513.300 480.000 524.500 ;
      LAYER Pwell ;
        RECT 0.000 510.000 7.800 513.300 ;
      LAYER Nwell ;
        RECT 7.800 510.000 480.000 513.300 ;
      LAYER Pwell ;
        RECT 0.000 509.500 480.000 510.000 ;
        RECT 0.000 498.300 0.500 509.500 ;
      LAYER Nwell ;
        RECT 0.500 498.300 480.000 509.500 ;
      LAYER Pwell ;
        RECT 0.000 495.000 7.800 498.300 ;
      LAYER Nwell ;
        RECT 7.800 495.000 480.000 498.300 ;
      LAYER Pwell ;
        RECT 0.000 494.500 480.000 495.000 ;
        RECT 0.000 483.300 0.500 494.500 ;
      LAYER Nwell ;
        RECT 0.500 483.300 480.000 494.500 ;
      LAYER Pwell ;
        RECT 0.000 480.000 7.800 483.300 ;
      LAYER Nwell ;
        RECT 7.800 480.000 480.000 483.300 ;
      LAYER Pwell ;
        RECT 0.000 479.500 480.000 480.000 ;
        RECT 0.000 468.300 0.500 479.500 ;
      LAYER Nwell ;
        RECT 0.500 468.300 480.000 479.500 ;
      LAYER Pwell ;
        RECT 0.000 465.000 7.800 468.300 ;
      LAYER Nwell ;
        RECT 7.800 465.000 480.000 468.300 ;
      LAYER Pwell ;
        RECT 0.000 464.500 480.000 465.000 ;
        RECT 0.000 453.300 0.500 464.500 ;
      LAYER Nwell ;
        RECT 0.500 453.300 480.000 464.500 ;
      LAYER Pwell ;
        RECT 0.000 450.000 7.800 453.300 ;
      LAYER Nwell ;
        RECT 7.800 450.000 480.000 453.300 ;
      LAYER Pwell ;
        RECT 0.000 449.500 480.000 450.000 ;
        RECT 0.000 438.300 0.500 449.500 ;
      LAYER Nwell ;
        RECT 0.500 438.300 480.000 449.500 ;
      LAYER Pwell ;
        RECT 0.000 435.000 7.800 438.300 ;
      LAYER Nwell ;
        RECT 7.800 435.000 480.000 438.300 ;
      LAYER Pwell ;
        RECT 0.000 434.500 480.000 435.000 ;
        RECT 0.000 423.300 0.500 434.500 ;
      LAYER Nwell ;
        RECT 0.500 423.300 480.000 434.500 ;
      LAYER Pwell ;
        RECT 0.000 420.000 7.800 423.300 ;
      LAYER Nwell ;
        RECT 7.800 420.000 480.000 423.300 ;
      LAYER Pwell ;
        RECT 0.000 419.500 480.000 420.000 ;
        RECT 0.000 408.300 0.500 419.500 ;
      LAYER Nwell ;
        RECT 0.500 408.300 480.000 419.500 ;
      LAYER Pwell ;
        RECT 0.000 405.000 7.800 408.300 ;
      LAYER Nwell ;
        RECT 7.800 405.000 480.000 408.300 ;
      LAYER Pwell ;
        RECT 0.000 404.500 480.000 405.000 ;
        RECT 0.000 393.300 0.500 404.500 ;
      LAYER Nwell ;
        RECT 0.500 393.300 480.000 404.500 ;
      LAYER Pwell ;
        RECT 0.000 390.000 7.800 393.300 ;
      LAYER Nwell ;
        RECT 7.800 390.000 480.000 393.300 ;
      LAYER Pwell ;
        RECT 0.000 389.500 480.000 390.000 ;
        RECT 0.000 378.300 0.500 389.500 ;
      LAYER Nwell ;
        RECT 0.500 378.300 480.000 389.500 ;
      LAYER Pwell ;
        RECT 0.000 375.000 7.800 378.300 ;
      LAYER Nwell ;
        RECT 7.800 375.000 480.000 378.300 ;
      LAYER Pwell ;
        RECT 0.000 374.500 480.000 375.000 ;
        RECT 0.000 363.300 0.500 374.500 ;
      LAYER Nwell ;
        RECT 0.500 363.300 480.000 374.500 ;
      LAYER Pwell ;
        RECT 0.000 360.000 7.800 363.300 ;
      LAYER Nwell ;
        RECT 7.800 360.000 480.000 363.300 ;
      LAYER Pwell ;
        RECT 0.000 359.500 480.000 360.000 ;
        RECT 0.000 348.300 0.500 359.500 ;
      LAYER Nwell ;
        RECT 0.500 348.300 480.000 359.500 ;
      LAYER Pwell ;
        RECT 0.000 345.000 7.800 348.300 ;
      LAYER Nwell ;
        RECT 7.800 345.000 480.000 348.300 ;
      LAYER Pwell ;
        RECT 0.000 344.500 480.000 345.000 ;
        RECT 0.000 333.300 0.500 344.500 ;
      LAYER Nwell ;
        RECT 0.500 333.300 480.000 344.500 ;
      LAYER Pwell ;
        RECT 0.000 330.000 7.800 333.300 ;
      LAYER Nwell ;
        RECT 7.800 330.000 480.000 333.300 ;
      LAYER Pwell ;
        RECT 0.000 329.500 480.000 330.000 ;
        RECT 0.000 318.300 0.500 329.500 ;
      LAYER Nwell ;
        RECT 0.500 318.300 480.000 329.500 ;
      LAYER Pwell ;
        RECT 0.000 315.000 7.800 318.300 ;
      LAYER Nwell ;
        RECT 7.800 315.000 480.000 318.300 ;
      LAYER Pwell ;
        RECT 0.000 314.500 480.000 315.000 ;
        RECT 0.000 303.300 0.500 314.500 ;
      LAYER Nwell ;
        RECT 0.500 303.300 480.000 314.500 ;
      LAYER Pwell ;
        RECT 0.000 300.000 7.800 303.300 ;
      LAYER Nwell ;
        RECT 7.800 300.000 480.000 303.300 ;
      LAYER Pwell ;
        RECT 0.000 299.500 480.000 300.000 ;
        RECT 0.000 288.300 0.500 299.500 ;
      LAYER Nwell ;
        RECT 0.500 288.300 480.000 299.500 ;
      LAYER Pwell ;
        RECT 0.000 285.000 7.800 288.300 ;
      LAYER Nwell ;
        RECT 7.800 285.000 480.000 288.300 ;
      LAYER Pwell ;
        RECT 0.000 284.500 480.000 285.000 ;
        RECT 0.000 273.300 0.500 284.500 ;
      LAYER Nwell ;
        RECT 0.500 273.300 480.000 284.500 ;
      LAYER Pwell ;
        RECT 0.000 270.000 7.800 273.300 ;
      LAYER Nwell ;
        RECT 7.800 270.000 480.000 273.300 ;
      LAYER Pwell ;
        RECT 0.000 269.500 480.000 270.000 ;
        RECT 0.000 258.300 0.500 269.500 ;
      LAYER Nwell ;
        RECT 0.500 258.300 480.000 269.500 ;
      LAYER Pwell ;
        RECT 0.000 255.000 7.800 258.300 ;
      LAYER Nwell ;
        RECT 7.800 255.000 480.000 258.300 ;
      LAYER Pwell ;
        RECT 0.000 254.500 480.000 255.000 ;
        RECT 0.000 243.300 0.500 254.500 ;
      LAYER Nwell ;
        RECT 0.500 243.300 480.000 254.500 ;
      LAYER Pwell ;
        RECT 0.000 240.000 7.800 243.300 ;
      LAYER Nwell ;
        RECT 7.800 240.000 480.000 243.300 ;
      LAYER Pwell ;
        RECT 0.000 239.500 480.000 240.000 ;
        RECT 0.000 228.300 0.500 239.500 ;
      LAYER Nwell ;
        RECT 0.500 228.300 480.000 239.500 ;
      LAYER Pwell ;
        RECT 0.000 225.000 7.800 228.300 ;
      LAYER Nwell ;
        RECT 7.800 225.000 480.000 228.300 ;
      LAYER Pwell ;
        RECT 0.000 224.500 480.000 225.000 ;
        RECT 0.000 213.300 0.500 224.500 ;
      LAYER Nwell ;
        RECT 0.500 213.300 480.000 224.500 ;
      LAYER Pwell ;
        RECT 0.000 210.000 7.800 213.300 ;
      LAYER Nwell ;
        RECT 7.800 210.000 480.000 213.300 ;
      LAYER Pwell ;
        RECT 0.000 209.500 480.000 210.000 ;
        RECT 0.000 198.300 0.500 209.500 ;
      LAYER Nwell ;
        RECT 0.500 198.300 480.000 209.500 ;
      LAYER Pwell ;
        RECT 0.000 195.000 7.800 198.300 ;
      LAYER Nwell ;
        RECT 7.800 195.000 480.000 198.300 ;
      LAYER Pwell ;
        RECT 0.000 194.500 480.000 195.000 ;
        RECT 0.000 183.300 0.500 194.500 ;
      LAYER Nwell ;
        RECT 0.500 183.300 480.000 194.500 ;
      LAYER Pwell ;
        RECT 0.000 180.000 7.800 183.300 ;
      LAYER Nwell ;
        RECT 7.800 180.000 480.000 183.300 ;
      LAYER Pwell ;
        RECT 0.000 179.500 480.000 180.000 ;
        RECT 0.000 168.300 0.500 179.500 ;
      LAYER Nwell ;
        RECT 0.500 168.300 480.000 179.500 ;
      LAYER Pwell ;
        RECT 0.000 165.000 7.800 168.300 ;
      LAYER Nwell ;
        RECT 7.800 165.000 480.000 168.300 ;
      LAYER Pwell ;
        RECT 0.000 164.500 480.000 165.000 ;
        RECT 0.000 153.300 0.500 164.500 ;
      LAYER Nwell ;
        RECT 0.500 153.300 480.000 164.500 ;
      LAYER Pwell ;
        RECT 0.000 150.000 7.800 153.300 ;
      LAYER Nwell ;
        RECT 7.800 150.000 480.000 153.300 ;
      LAYER Pwell ;
        RECT 0.000 149.500 480.000 150.000 ;
        RECT 0.000 138.300 0.500 149.500 ;
      LAYER Nwell ;
        RECT 0.500 138.300 480.000 149.500 ;
      LAYER Pwell ;
        RECT 0.000 135.000 7.800 138.300 ;
      LAYER Nwell ;
        RECT 7.800 135.000 480.000 138.300 ;
      LAYER Pwell ;
        RECT 0.000 134.500 480.000 135.000 ;
        RECT 0.000 123.300 0.500 134.500 ;
      LAYER Nwell ;
        RECT 0.500 123.300 480.000 134.500 ;
      LAYER Pwell ;
        RECT 0.000 120.000 7.800 123.300 ;
      LAYER Nwell ;
        RECT 7.800 120.000 480.000 123.300 ;
      LAYER Pwell ;
        RECT 0.000 119.500 480.000 120.000 ;
        RECT 0.000 108.300 0.500 119.500 ;
      LAYER Nwell ;
        RECT 0.500 108.300 480.000 119.500 ;
      LAYER Pwell ;
        RECT 0.000 105.000 7.800 108.300 ;
      LAYER Nwell ;
        RECT 7.800 105.000 480.000 108.300 ;
      LAYER Pwell ;
        RECT 0.000 104.500 480.000 105.000 ;
        RECT 0.000 93.300 0.500 104.500 ;
      LAYER Nwell ;
        RECT 0.500 93.300 480.000 104.500 ;
      LAYER Pwell ;
        RECT 0.000 90.000 7.800 93.300 ;
      LAYER Nwell ;
        RECT 7.800 90.000 480.000 93.300 ;
      LAYER Pwell ;
        RECT 0.000 89.500 480.000 90.000 ;
        RECT 0.000 78.300 0.500 89.500 ;
      LAYER Nwell ;
        RECT 0.500 78.300 480.000 89.500 ;
      LAYER Pwell ;
        RECT 0.000 75.000 7.800 78.300 ;
      LAYER Nwell ;
        RECT 7.800 75.000 480.000 78.300 ;
      LAYER Pwell ;
        RECT 0.000 74.500 480.000 75.000 ;
        RECT 0.000 63.300 0.500 74.500 ;
      LAYER Nwell ;
        RECT 0.500 63.300 480.000 74.500 ;
      LAYER Pwell ;
        RECT 0.000 60.000 7.800 63.300 ;
      LAYER Nwell ;
        RECT 7.800 60.000 480.000 63.300 ;
      LAYER Pwell ;
        RECT 0.000 59.500 480.000 60.000 ;
        RECT 0.000 48.300 0.500 59.500 ;
      LAYER Nwell ;
        RECT 0.500 48.300 480.000 59.500 ;
      LAYER Pwell ;
        RECT 0.000 45.000 7.800 48.300 ;
      LAYER Nwell ;
        RECT 7.800 45.000 480.000 48.300 ;
      LAYER Pwell ;
        RECT 0.000 44.500 480.000 45.000 ;
        RECT 0.000 33.300 0.500 44.500 ;
      LAYER Nwell ;
        RECT 0.500 33.300 480.000 44.500 ;
      LAYER Pwell ;
        RECT 0.000 30.000 7.800 33.300 ;
      LAYER Nwell ;
        RECT 7.800 30.000 480.000 33.300 ;
      LAYER Pwell ;
        RECT 0.000 29.500 480.000 30.000 ;
        RECT 0.000 18.300 0.500 29.500 ;
      LAYER Nwell ;
        RECT 0.500 18.300 480.000 29.500 ;
      LAYER Pwell ;
        RECT 0.000 15.000 7.800 18.300 ;
      LAYER Nwell ;
        RECT 7.800 15.000 480.000 18.300 ;
      LAYER Pwell ;
        RECT 0.000 14.500 480.000 15.000 ;
        RECT 0.000 3.300 0.500 14.500 ;
      LAYER Nwell ;
        RECT 0.500 3.300 480.000 14.500 ;
      LAYER Pwell ;
        RECT 0.000 0.000 7.800 3.300 ;
      LAYER Nwell ;
        RECT 7.800 0.000 480.000 3.300 ;
      LAYER Metal1 ;
        RECT 0.000 0.000 480.000 987.400 ;
      LAYER Metal2 ;
        RECT 0.000 0.000 480.000 986.900 ;
      LAYER Metal3 ;
        RECT 0.000 0.000 480.000 985.300 ;
      LAYER Metal4 ;
        RECT 0.100 0.000 479.700 985.300 ;
      LAYER Metal5 ;
        RECT 97.500 973.500 211.000 985.500 ;
  END
END ip_pixel_column_n
END LIBRARY

