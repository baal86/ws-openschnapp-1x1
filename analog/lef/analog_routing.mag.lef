VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO analog_routing
  CLASS COVER ;
  FOREIGN analog_routing ;
  ORIGIN -442.400 -442.960 ;
  SIZE 1.000 BY 1.000 ;
  OBS
      LAYER Metal2 ;
        RECT 375.000 1380.000 380.000 1425.000 ;
        RECT 375.000 1375.000 450.000 1380.000 ;
        RECT 445.000 1025.000 450.000 1375.000 ;
        RECT 445.000 1020.000 510.000 1025.000 ;
  END
END analog_routing
END LIBRARY

